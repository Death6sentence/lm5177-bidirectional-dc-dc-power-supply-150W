# Keil uVision project LM5177MCU.uvprojx, settings and files
target LM5177MCU (6240000::V6.24::ARMCLANG)
  device: STM32G431KBTx STMicroelectronics
  pack: Keil.STM32G4xx_DFP.2.2.0
  cpu: IRAM(0x20000000-0x20007FFF) IROM(0x8000000-0x801FFFF)  CLOCK(8000000) FPU2 CPUTYPE("Cortex-M4") TZ
  output: LM5177MCU +hex
  c flags: Optim=4 OneElfS=1 uC99=1 v6Lang=3 v6LangP=3 wLevel=3
  c define: USE_HAL_DRIVER,STM32G431xx,HSE_VALUE=25000000U
  c include: ../Core/Inc;../App;../BSP/ADC;../BSP/NTC;../BSP/FAN;../BSP/Button;../BSP/DAC;../BSP/Encoder;../BSP/GPIO;../BSP/OLED;../BSP/PWM;../Drivers/STM32G4xx_HAL_Driver/Inc;../Drivers/STM32G4xx_HAL_Driver/Inc/Legacy;../Drivers/CMSIS/Device/ST/STM32G4xx/Include;../Drivers/CMSIS/Include
  memory RVCT4: ROM 0x8000000 size 0x20000
  memory RVCT9: RAM 0x20000000 size 0x8000
  group Application/MDK-ARM
    ./: startup_stm32g431xx.s
  group Application/User/Core
    ../Core/Src/: main.c gpio.c adc.c dac.c fmac.c i2c.c opamp.c tim.c usart.c stm32g4xx_it.c stm32g4xx_hal_msp.c
  group Application/User/App
    ../App/: app.c app_telemetry.c app_menu.c app_status.c cc_pid.c vout_filter.c
  group Application/User/BSP/ADC
    ../BSP/ADC/: bsp_adc.c
  group Application/User/BSP/NTC
    ../BSP/NTC/: bsp_ntc.c
  group Application/User/BSP/FAN
    ../BSP/FAN/: bsp_fan.c
  group Application/User/BSP/Button
    ../BSP/Button/: bsp_button.c
  group Application/User/BSP/DAC
    ../BSP/DAC/: bsp_dac.c
  group Application/User/BSP/Encoder
    ../BSP/Encoder/: bsp_encoder.c
  group Application/User/BSP/GPIO
    ../BSP/GPIO/: bsp_gpio.c
  group Application/User/BSP/OLED
    ../BSP/OLED/: oled.c font.c
  group Application/User/BSP/PWM
    ../BSP/PWM/: bsp_pwm.c
  group Drivers/STM32G4xx_HAL_Driver
    ../Drivers/STM32G4xx_HAL_Driver/Src/: stm32g4xx_hal_adc.c stm32g4xx_hal_adc_ex.c stm32g4xx_ll_adc.c stm32g4xx_hal.c stm32g4xx_hal_rcc.c stm32g4xx_hal_rcc_ex.c stm32g4xx_hal_flash.c stm32g4xx_hal_flash_ex.c stm32g4xx_hal_flash_ramfunc.c stm32g4xx_hal_gpio.c stm32g4xx_hal_exti.c stm32g4xx_hal_dma.c stm32g4xx_hal_dma_ex.c stm32g4xx_hal_pwr.c stm32g4xx_hal_pwr_ex.c stm32g4xx_hal_cortex.c stm32g4xx_hal_dac.c stm32g4xx_hal_dac_ex.c stm32g4xx_hal_fmac.c stm32g4xx_hal_i2c.c stm32g4xx_hal_i2c_ex.c stm32g4xx_hal_opamp.c stm32g4xx_hal_opamp_ex.c stm32g4xx_hal_tim.c stm32g4xx_hal_tim_ex.c stm32g4xx_hal_uart.c stm32g4xx_hal_uart_ex.c
  group Drivers/CMSIS
    ../Core/Src/: system_stm32g4xx.c
software components: CMSIS:CORE 6.2.0, CMSIS:DSP 1.16.2
